Commit message: added timing signal and slot

File: models/drchubo_v2/robots/drchubo_v2.urdf (robot description, URDF)
Before this commit: robot drchubo_v2, 56 links, 55 joints
Joints:
- joint LF32: axis (none) -> 0 -1 0
